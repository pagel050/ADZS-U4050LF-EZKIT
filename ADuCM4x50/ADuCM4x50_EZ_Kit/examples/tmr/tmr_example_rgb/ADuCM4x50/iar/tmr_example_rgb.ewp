# IAR project tmr_example_rgb.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__
  ICCARM.CCIncludePath2: ..\..\..\..\..\Include\; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ILINK.IlinkOutputFile: tmr_example_rgb.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_tmr_example_rgb.txt
  group Driver
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/tmr/: adi_tmr.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
  group Source
    ../: adi_pinmuxing.c
    ../../: tmr_example_rgb.c tmr_example_rgb.h
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
