# IAR project crypto_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: config; ..\..\..\..\Include\config; ..\..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: crypto_example.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: crypto_example.c
    ../: Readme_crypto.txt
  group Driver Sources
    ../../../../Source/drivers/crypto/: adi_crypto.c
    ../../../../Source/drivers/dma/: adi_dma.c
    ../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../Source/drivers/uart/: adi_uart.c
    ../../../../Source/drivers/wdt/: adi_wdt.c
  group System Sources
    ../../../../Source/: common.c system_ADuCM4050.c
    ../../../../Source/IAR/: startup_ADuCM4050.s
