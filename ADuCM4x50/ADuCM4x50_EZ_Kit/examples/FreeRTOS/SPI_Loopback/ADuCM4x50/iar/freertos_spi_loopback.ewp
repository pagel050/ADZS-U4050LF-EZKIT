# IAR project freertos_spi_loopback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\inc; ..\..\inc\config; ..\..\..\..\..\Include\; ..\..\..\..\..\Include\rtos_map; ..\..\..\..\..\Include\config; $_ADI_FREERTOS_PATH_$\include; $_ADI_FREERTOS_PATH_$\portable\IAR\ARM_CM4F; $_ADI_FREERTOS_PATH_PLUS_$\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\inc; ..\..\inc\config; ..\..\..\..\..\Include\; ..\..\..\..\..\Include\rtos_map; ..\..\..\..\..\Include\config; $_ADI_FREERTOS_PATH_$\include; $_ADI_FREERTOS_PATH_$\portable\IAR\ARM_CM4F; $_ADI_FREERTOS_PATH_PLUS_$\Include; $_ADI_FREERTOS_PATH_PLUS_$\Config
  OBJCOPY.OOCOutputFile: freertos_test.srec
  ILINK.IlinkOutputFile: freertos_spi_loopback.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\inc; ..\..\inc\config; ..\..\..\..\..\Include\; ..\..\..\..\..\Include\rtos_map; ..\..\..\..\..\Include\config; $_ADI_FREERTOS_PATH_$\include; $_ADI_FREERTOS_PATH_$\portable\IAR\ARM_CM4F
  group (top)
    ../../: Readme_freertos_spi_loopback.txt
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/spi/: adi_spi.c
  group FreeRTOS
    $_ADI_FREERTOS_PATH_$/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/config
    ../../inc/: FreeRTOSConfig.h
  group FreeRTOS/include
    $_ADI_FREERTOS_PATH_$/include/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/portable/IAR/ARM_CM4F
    $_ADI_FREERTOS_PATH_$/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
  group FreeRTOS+Trace
    $_ADI_FREERTOS_PATH_PLUS_$/: trcBase.c trcHardwarePort.c trcKernel.c trcKernelPort.c trcUser.c
  group FreeRTOS+Trace/Include
    $_ADI_FREERTOS_PATH_PLUS_$/Include/: trcBase.h trcHardwarePort.h trcKernel.h trcKernelHooks.h trcKernelPort.h trcTypes.h trcUser.h
  group Include
    ../../../../../Include/rtos_map/: adi_rtos_map_freertos.h
  group Include/config
    ../../inc/config/: adi_global_config.h trcConfig.h
  group Source
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../../: PinMux.c spi_loopback_freertos.c spi_master_task.c spi_slave_task.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
