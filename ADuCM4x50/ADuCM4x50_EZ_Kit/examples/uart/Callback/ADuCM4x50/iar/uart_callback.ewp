# IAR project uart_callback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: uart_callback.srec
  ILINK.IlinkOutputFile: uart_callback.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/uart/: adi_uart.c
    ../../../../../Source/drivers/wdt/: adi_wdt.c
  group Source
    ../../: uart_callback.c
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../: PinMux.c Readme_uart_callback.txt
    ../../../../../Source/IAR/: startup_ADuCM4050.s
