# IAR project adc_channel_read.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_adc_channel_read.txt
  group config
    ../../config/: adi_adc_config.h
  group Driver
    ../../../../../Source/drivers/adc/: adi_adc.c
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/wdt/: adi_wdt.c
  group Source
    ../../: adc_channel_read.c
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../: PinMux.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
