<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\core_driven_crc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


