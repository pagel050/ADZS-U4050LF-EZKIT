# IAR project w25q32_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__
  ICCARM.CCIncludePath2: ..\..\..\..\..\Include\; ..\..\config; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ILINK.IlinkOutputFile: w25q32_example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_w25q32_example.txt
  group Config
    ../../config/: adi_spi_config.h
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/spi/: adi_spi.c
    ../../../../../Source/drivers/spi-flash/w25q32/: adi_w25q32.c
  group Source
    ../../: w25q32_example.c
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../: PinMux.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
