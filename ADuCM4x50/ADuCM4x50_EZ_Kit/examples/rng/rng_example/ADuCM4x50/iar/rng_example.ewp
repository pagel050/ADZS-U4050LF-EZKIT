# IAR project rng_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_rng_example.txt
  group Driver
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/rng/: adi_rng.c
    ../../../../../Source/: common.c
  group Source
    ../../: rng_example.c rng_example.h
  group System
    ../../../../../Source/IAR/: startup_ADuCM4050.s
    ../../../../../Source/: system_ADuCM4050.c
