# IAR project POST.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; POST_COMMON_USES_UART; __ADUCM4050__; __ADUCM4x50__; EZKIT_REV_1_0
  ICCARM.CCIncludePath2: ../config; ../../../../Include; ../../../../Include/config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: POST_COMMON_USES_UART; __ADUCM4050__; __ADUCM4x50__; EZKIT_REV_1_0
  AARM.AUserIncludes: ../../../../Include; ../../../../Include/config
  OBJCOPY.OOCOutputFile: POST.bin
  ILINK.IlinkOutputFile: POST.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; POST_COMMON_USES_UART; __ADUCM4050__; __ADUCM4x50__; EZKIT_REV_1_0
  ICCARM.CCIncludePath2: ../../../../Include; ../../../../osal/noos/Source; ../../../../Include/config
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: POST.srec
  group (top)
    ../: adc_test.c adxl363_test.c beep_test.c flash_page_write.h lfx_test.c main.c pbled_test.c pbled_test.h post_common.c post_common.h post_pinmux.c processor_version_test.c rgb_pinmux.c rgb_tmr_test.c rtc_test.c spi_flash_test.c timer_isr.c timer_isr.h tmr_example_rgb.h twi_temp_test.c uart_test.c wakeup_button.h wakeup_test.c
  group Drivers
    ../../../../Source/drivers/adc/: adi_adc.c
    ../../../../Source/drivers/adxl363/: adi_adxl363.c
    ../../../../Source/drivers/beep/: adi_beep.c
    ../../../../Source/drivers/dma/: adi_dma.c
    ../../../../Source/drivers/flash/: adi_flash.c
    ../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../Source/drivers/i2c/: adi_i2c.c
    ../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../Source/drivers/rtc/: adi_rtc.c
    ../../../../Source/drivers/spi/: adi_spi.c
    ../../../../Source/drivers/tmr/: adi_tmr.c
    ../../../../Source/drivers/uart/: adi_uart.c
    ../../../../Source/drivers/wdt/: adi_wdt.c
    ../../../../Source/drivers/xint/: adi_xint.c
  group System Sources
    ../../../../Source/IAR/: startup_ADuCM4050.s
    ../../../../Source/: system_ADuCM4050.c
