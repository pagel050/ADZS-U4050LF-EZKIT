# IAR project wakeup_button.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  OBJCOPY.OOCOutputFile: temperature_sensor.srec
  ILINK.IlinkOutputFile: wakeup_button.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: wakeup_button.srec
  group (top)
    ../: Readme_wakeup_button.txt
  group Driver
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/xint/: adi_xint.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
  group Source
    ../../: wakeup_button.c
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
