# IAR project wdt_example_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ILINK.IlinkOutputFile: wdt_example_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: wdt_example_interrupt.srec
  group (top)
    ../: Readme_wdt_example_interrupt.txt
  group config
    ../../config/: adi_global_config.h adi_tmr_config.h adi_wdt_config.h
  group Driver
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/tmr/: adi_tmr.c
    ../../../../../Source/drivers/wdt/: adi_wdt.c
  group Source
    ../../: wdt_example_interrupt.c wdt_example_interrupt.h
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
