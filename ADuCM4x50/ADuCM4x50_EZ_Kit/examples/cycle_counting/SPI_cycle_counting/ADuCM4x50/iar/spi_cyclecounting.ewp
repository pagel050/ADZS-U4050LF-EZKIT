# IAR project spi_cyclecounting.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG
  ICCARM.CCIncludePath2: ../../../../../Include; ../../config; ../../../../../Include/config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  OBJCOPY.OOCOutputFile: spi_cyclecounting.srec
  ILINK.IlinkOutputFile: spi_cyclecounting.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_spi_cyclecounting.txt
  group config
    ../../config/: adi_cycle_counting_config.h
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/spi/: adi_spi.c
  group Source
    ../../: spi_cyclecounting.c
  group System
    ../../../../../Source/: adi_cyclecount.c common.c system_ADuCM4050.c
    ../: PinMux.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
