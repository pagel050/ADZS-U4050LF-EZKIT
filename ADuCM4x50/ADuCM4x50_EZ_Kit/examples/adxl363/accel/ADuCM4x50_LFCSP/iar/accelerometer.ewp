# IAR project accelerometer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG
  ICCARM.CCIncludePath2: ../../../../../Include; ../../config; ../../../../../Include/config; ../../../../../Include/rtos_map
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: accelerometer.out
  ILINK.IlinkExtraOptions: --keep __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: adxl363_accel.c
    ../../../../../Source/: common.c
    ../: Readme_adxl363_example.txt
  group config
    ../../config/: adi_adxl363_config.h adi_spi_config.h
  group Driver
    ../../../../../Source/drivers/adxl363/: adi_adxl363.c
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/spi/: adi_spi.c
    ../../../../../Source/drivers/wdt/: adi_wdt.c
  group System
    ../: adi_pinmux.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
    ../../../../../Source/: system_ADuCM4050.c
