# IAR project systick_example.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\..\Include\config; ..\..\..\..\..\Include
  ILINK.IlinkOutputFile: systick_example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: Readme_systick_example.txt
  group Drivers
    ../../../../../Source/drivers/pwr/: adi_pwr.c
  group Source
    ../../: systick_example.c systick_example.h
  group System
    ../../../../../Source/: common.c system_ADuCM4050.c
    ../../../../../Source/IAR/: startup_ADuCM4050.s
