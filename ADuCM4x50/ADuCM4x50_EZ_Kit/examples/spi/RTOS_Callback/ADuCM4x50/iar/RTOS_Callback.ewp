# IAR project RTOS_Callback.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include\config; ..\..\..\..\..\Include; $_ADUCM4x50_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M4\IAR; $_ADUCM4x50_MICRIUM_DIR_$\uC-CPU\; $_ADUCM4x50_MICRIUM_DIR_$\uC-LIB\; $_ADUCM4x50_MICRIUM_DIR_$\; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III\Source; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III; $_ADUCM4x50_MICRIUM_DIR_$\uCOS-III\Ports\ARM-Cortex-M\ARMv7-M\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  group (top)
    ../: Readme_RTOS_Callback.txt
  group config
    ../../config/: adi_global_config.h adi_spi_config.h cpu_cfg.h lib_cfg.h os_cfg.h os_cfg_app.h
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
    ../../../../../Source/drivers/spi/: adi_spi.c
    ../../../../../Source/: common.c
  group Micrium/uC-CPU
    $_ADUCM4x50_MICRIUM_DIR_$/uC-CPU/: cpu_core.c
  group Micrium/uC-CPU/IAR
    $_ADUCM4x50_MICRIUM_DIR_$/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
  group Micrium/uC-LIB
    $_ADUCM4x50_MICRIUM_DIR_$/uC-LIB/: lib_mem.c lib_str.c
  group Micrium/uCOS-III/Ports
    $_ADUCM4x50_MICRIUM_DIR_$/uCOS-III/Ports/ARM-Cortex-M/ARMv7-M/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group Micrium/uCOS-III/Source
    $_ADUCM4x50_MICRIUM_DIR_$/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group Micrium/uCOS-III/TLS
    $_ADUCM4x50_MICRIUM_DIR_$/uCOS-III/TLS/IAR/: os_tls.c
  group Source
    ../../: os_app_hooks.c PinMux.c RTOS_Callback.c SPI_Master.c SPI_Slave.c
  group System
    ../../../../../Source/IAR/: startup_ADuCM4050.s
    ../../../../../Source/: system_ADuCM4050.c
