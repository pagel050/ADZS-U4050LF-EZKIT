# IAR project flash_block_protect.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM4050 AnalogDevices ADuCM4050
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ADI_DEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCIncludePath2: ..\..\config; ..\..\..\..\..\Include; ..\..\..\..\..\Include\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkKeepSymbols: __checksum
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ADUCM4050__; __ADUCM4x50__
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: flash_block_protect.srec
  group (top)
    ../: Readme_flash_block_protect.txt
  group Driver
    ../../../../../Source/drivers/dma/: adi_dma.c
    ../../../../../Source/drivers/flash/: adi_flash.c
    ../../../../../Source/drivers/gpio/: adi_gpio.c
    ../../../../../Source/drivers/pwr/: adi_pwr.c
  group Source
    ../../../../../Source/: common.c
    ../../: flash_block_protect.c
  group System
    ../../../../../Source/IAR/: startup_ADuCM4050.s
    ../../../../../Source/: system_ADuCM4050.c
